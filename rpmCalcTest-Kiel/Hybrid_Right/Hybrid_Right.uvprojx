# Keil uVision project Hybrid_Right.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Hybrid_Right
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: right_main.c
  group CommonLibs
    ../Common/: PLL.c PLL.h startup_TM4C123.s SysTick.c SysTick.h TM4C123GH6PM.h UART.c UART.h
  group Common
    ../Common/: init.h init.c common_main.h pidController.c pidController.h common_main.c
